<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\inc\core_cm4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\core_cm4_simd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\core_cmFunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\core_cmInstr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\csr8670_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\gsensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\gsensor_ahrs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\gsensor_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\pxialg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\pxialg_dyn.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\sensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\sensor_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_pwr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_rcc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_syscfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_tim.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\stm32f4xx_usart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\system_stm32f4xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\uvsensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\uvsensor_i2c.h</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\startup\startup_stm32f4xx.s</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\CSR8670_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\gsensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\gsensor_ahrs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\gsensor_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\sensor_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\sensor_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\system_stm32f4xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\uvsensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\uvSensor_i2c.c</name>
    </file>
  </group>
</project>


