# IAR project TestG.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405OE ST STM32F405OE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F4XX; xVECT_TAB_SRAM
  ICCARM.CCIncludePath2: D:\STM32F407 Project\2015_0302_I2CBURST_NOTIMER_OK\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestG.srec
  ILINK.IlinkOutputFile: STM32F4_Test.bin
  ILINK.IlinkIcfFile: D:\STM32F407 Project\2015_0302_I2CBURST_NOTIMER_OK\stm32f40x_flash.icf
  ILINK.IlinkAdditionalLibs: D:\STM32F407 Project\2015_0302_I2CBURST_NOTIMER_OK\lib\paw8001motion23_stm32f407_iar.lib; D:\STM32F407 Project\2015_0302_I2CBURST_NOTIMER_OK\lib\paw8001sdnn48_stm32f407_iar.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group inc
    inc/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h csr8670_uart.h gsensor.h gsensor_ahrs.h gsensor_i2c.h misc.h pxialg.h pxialg_dyn.h sensor.h sensor_i2c.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_it.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h system_stm32f4xx.h uvsensor.h uvsensor_i2c.h
  group startup
    startup/: startup_stm32f4xx.s
  group user
    user/: CSR8670_uart.c gsensor.c gsensor_ahrs.c gsensor_i2c.c main.c misc.c sensor.c sensor_i2c.c sensor_led.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c uvsensor.c uvSensor_i2c.c
